# Keil uVision project main.uvproj, settings and files
target MACSD (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51
    ./source/: main.c
  group Device
    ./source/: 18B20.c buzzer.c ComCDT.c delay.c IKeyEvent.c Relay.c
